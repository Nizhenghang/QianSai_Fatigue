# Keil uVision project zf_ra_motherboard_demo.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.6.4.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: zf_ra_motherboard_demo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\zf_libraries\common;..\zf_libraries\drivers;..\zf_libraries\devices;..\zf_libraries\code;.\code
  library: MicroLIB
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
  group code
    ./code/: fatigue_detect.c r_usb_pcdc_descriptor.c zf_driver_usb_cdc.c zf_driver_usb_cdc.h cnn_inference.c hmi_display.c voice_assistant.c audio_player.c image_export.c image_export.h cnn_inference.h hmi_display.h voice_assistant.h audio_player.h audio_samples.h
  group doc
    ../zf_libraries/doc/: version.txt
  group zf_common
    ../zf_libraries/common/: zf_common_headfile.h zf_common_fifo.c zf_common_fifo.h zf_common_debug.c zf_common_debug.h zf_common_function.c zf_common_function.h
  group zf_drivers
    ../zf_libraries/drivers/: zf_driver_gpio.c zf_driver_gpio.h zf_driver_delay.c zf_driver_delay.h zf_driver_soft_iic.c zf_driver_soft_iic.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_encoder.c zf_driver_encoder.h zf_driver_adc.c zf_driver_adc.h zf_driver_dac.c zf_driver_dac.h ra_driver_sdram.c ra_driver_sdram.h zf_driver_uart.c zf_driver_uart.h zf_driver_sd.c zf_driver_sd.h zf_driver_pit.c zf_driver_pit.h
  group zf_devices
    ../zf_libraries/devices/: zf_device_imu660ra.c zf_device_imu660ra.h zf_device_config.lib zf_device_config.h zf_device_wifi_uart.c zf_device_wifi_uart.h zf_device_ips200pro.c zf_device_ips200pro.h zf_device_scc8660.c zf_device_scc8660.h zf_device_mt9v03x.c zf_device_mt9v03x.h
software components: Flex Software:RA Configuration 1.0.0
